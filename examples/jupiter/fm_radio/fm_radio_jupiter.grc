options:
  parameters:
    generate_options: qt_gui
    id: fm_radio_jupiter
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: profile_rate/audio_rate
  states: {}
- name: fm_frequency
  id: variable
  parameters:
    value: '105100000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: gain
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: profile_rate
  id: variable
  parameters:
    value: 48000*16
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: decimation*audio_rate
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: int(decimation)
    quad_rate: samp_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_rate
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: 2**15
  states: {}
- name: blocks_short_to_float_0_0
  id: blocks_short_to_float
  parameters:
    scale: 2**15
  states: {}
- name: iio_attr_sink_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: voltage0
    device: adrv9002-phy
    output: 'False'
    uri: ip:192.168.86.31
  states: {state: disabled}
- name: iio_attr_updater_0
  id: iio_attr_updater
  parameters:
    attr: hardwaregain
    interval: '1000'
    value: str(gain)
  states: {state: disabled}
- name: iio_device_source_0_0
  id: iio_device_source
  parameters:
    buffer_size: 2**20
    channels: '[''voltage0_i'', ''voltage0_q'']'
    decimation: '1'
    device: axi-adrv9002-rx-lpc
    device_phy: adrv9002-phy
    params: '[''out_altvoltage0_RX1_LO_frequency=''+str(fm_frequency)]'
    uri: ip:192.168.86.31
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [blocks_float_to_complex_0, '0', analog_wfm_rcv_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_short_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_short_to_float_0_0, '0', blocks_float_to_complex_0, '1']
- [iio_attr_updater_0, out, iio_attr_sink_0, attr]
- [iio_device_source_0_0, '0', blocks_short_to_float_0, '0']
- [iio_device_source_0_0, '1', blocks_short_to_float_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
